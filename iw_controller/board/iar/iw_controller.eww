<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\iw_controller.ewp</path>
    </project>
    <batchBuild />
</workspace>
